FILESEXTRAPATHS:prepend := "${THISDIR}/linux-raspberrypi/files:"
SRC_URI += "file://techleefbsp.cfg"